Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: c589641d-7e0a-4563-a72d-ef1138566a1c, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-07T16:07:51+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12431430_CH_FN4322D_WS:37432284_CH_12431430_FN4322D_WS, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_BRWS, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Connection_Modul, <Unnamed>, z_Miele_Design_Glass
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 1455 mm; Depth: 675 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 37432284_CH_12431430_FN4322D_WS; sets with these values: 2

# IfcDistributionPort, Port_355676_1
Description: Flow; FlowDirection: SOURCEANDSINK
